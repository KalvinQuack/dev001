# IAR project dev001.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C129XNCZAD TexasInstruments TM4C129XNCZAD
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; DEVICE_TM4C129; PART_TM4C129XNCZAD; TARGET_IS_TM4C129_RA0; _DEV001_DEVICE_
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\src; ..\modules\inc; ..\modules\src; ..\kOS\inc; ..\kOS\src; ..\middleware; ..\middleware\hw_interfaces\inc; ..\middleware\hw_interfaces\src; ..\middleware\TivaWare_C_Series-2.2.0.295; ..\application; ..\application\src; ..\application\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: dev001.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../middleware/hw_interfaces/src/: digitalInput_interface.c digitalOutput_interface.c systemControl_interface.c UART_interface.c
    ../modules/src/: serial.c
    ./: startup_ewarm.c
    ../middleware/hw_interfaces/inc/: systemControl_interface.h
  group Assembly
    ../kOS/asm/: context.s custom_cmain.s system_reset.s
  group Libraries
    ../modules/src/: buttons.c
    ../modules/inc/: buttons.h
    ../middleware/TivaWare_C_Series-2.2.0.295/driverlib/ewarm/Exe/: driverlib.a
  group pinmap
    ../middleware/: BSP.c pinmap.h
  group src
    ../kOS/src/: kernel.c queue.c
    ../application/src/: main_TMC129XNCZAD.c
    ../application/inc/: main_TMC129XNCZAD.h
    ../modules/src/: system_init.c
    ../modules/inc/: system_init.h
